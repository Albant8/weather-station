# Keil uVision project basic_BlueNRG_code.uvprojx, settings and files
target BlueNRG2 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: basic_BlueNRG_code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SMPS_INDUCTOR=SMPS_INDUCTOR_10uH LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ BLUENRG2_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_16MHZ USER_BUTTON=BUTTON_1
  c misc: --wchar32
  c include: .\inc\BlueNRG1;.\inc\BlueNRG1_Periph_Driver;.\inc\CMSIS;.\inc\hal;.\inc\main;.\inc\SDK;.\BeFC_Library\Inc;.\Screen_Library;.\Sensor
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  group HAL
    ./Hal/: clock.c miscutil.c osal.c sleep.c vtimer.c fifo.c hal_radio.c
  group Library
    ./Library/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_timer.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c BlueNRG1_radio.c
  group Platform_Layers
    ./Platforms_Layers/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_I2C.c SDK_EVAL_Led.c SDK_EVAL_SPI.c
  group Startup
    ./Hal/: context_switch.s
    ./Startup/: system_bluenrg1.c
  group User
    ./User/: BlueNRG1_it.c Main.c BlueNRG_Interface_Lib.c
    ./Screen_Library/: Screen.c
  group Sensor
    ./Sensor/: SHT4.c
software components: CMSIS:CORE 5.5.0
